# Keil uVision project TouchGFX.uvprojx, settings and files
target TouchGFX (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.12.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF)        CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: TouchGFX
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx
  c include: ../Inc;../Src;../Drivers/STM32F7xx_HAL_Driver/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../Drivers/CMSIS/Include;../middlewares/st/touchgfx/framework/include;../src/generated/fonts/include;../src/generated/gui_generated/include;../src/generated/images/include;../src/generated/texts/include;../src/gui/include;..\Src\ft5336
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
  group Application/User
    ../Src/: main.c freertos.c TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp TouchGFXHAL.cpp STM32TouchController.cpp STM32DMA.cpp OSWrappers.cpp TouchGFXGPIO.cpp app_touchgfx.c stm32f7xx_it.c stm32f7xx_hal_msp.c stm32f7xx_hal_timebase_tim.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_exti.c stm32f7xx_hal_dma2d.c stm32f7xx_ll_fmc.c stm32f7xx_hal_sdram.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_dsi.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
  group ft5336
    ../Src/ft5336/: ft5336.c stm32746g_discovery.c stm32746g_discovery_ts.c
  group gui
    ../src/gui/src/common/: frontendapplication.cpp
    ../src/gui/src/model/: model.cpp
    ../src/gui/src/screen_screen/: screenpresenter.cpp screenview.cpp
  group generated
    ../src/generated/fonts/src/: applicationfontprovider.cpp cachedfont.cpp font_verdana_10_4bpp_0.cpp font_verdana_20_4bpp_0.cpp font_verdana_40_4bpp_0.cpp fontcache.cpp generatedfont.cpp kerning_verdana_10_4bpp.cpp kerning_verdana_20_4bpp.cpp kerning_verdana_40_4bpp.cpp table_verdana_10_4bpp.cpp table_verdana_20_4bpp.cpp table_verdana_40_4bpp.cpp
    ../src/generated/images/src/: bitmapdatabase.cpp
    ../src/generated/images/src/__designer/: blue_buttons_round_edge_small.cpp blue_buttons_round_edge_small_pressed.cpp
    ../src/generated/gui_generated/src/common/: frontendapplicationbase.cpp
    ../src/generated/texts/src/: languagegb.cpp texts.cpp typedtextdatabase.cpp
    ../src/generated/gui_generated/src/screen_screen/: screenviewbase.cpp
  group Lib
    ../middlewares/st/touchgfx/lib/core/cortex_m7/Keil/: touchgfx_core.lib
software components: CMSIS:CORE 4.3.0
